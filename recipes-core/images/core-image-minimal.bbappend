IMAGE_INSTALL += " watchpoint"
inherit extrausers
EXTRA_USERS_PARAMS = "usermod -P 123 root;"